## sdk_patch/ramdisk/rootfs/public/rndis/Kconfig
```kconfig
config TARGET_PACKAGE_RNDIS
	bool "Target rndis"
	default n
	help
	  target rndis
```
